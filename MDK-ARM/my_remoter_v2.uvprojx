# Keil uVision project my_remoter_v2.uvprojx, settings and files
target my_remoter_v2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: my_remoter_v2 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../COMMON/interface;../COMMUNICATE/interface;../CONFIG/interface;../FreeRTOS/portable/RVDS/ARM_CM3;../FreeRTOS/include;../GUI_APP/interface;../GUI_DRV/interface;../Hardware/Inc;../USB/STM32_USB-FS-Device_Driver/inc;../USB/CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group CONFIG
    ../CONFIG/src/: config_param.c
    ../CONFIG/interface/: config_param.h
  group COMMUNICATE
    ../COMMUNICATE/src/: atkp.c beep.c joystick.c keyTask.c radiolink.c remoter_ctrl.c usblink.c
  group GUI_APP
    ../GUI_APP/src/: debug_ui.c display.c joystickCalib_ui.c main_ui.c match_ui.c menu_ui.c menuL1_item.c menuL2_item.c menuL3_item.c reset_ui.c trim_ui.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c
  group Hardware
    ../Hardware/Src/: oled.c 24l01.c key.c led.c stmflash.c my_adc.c font.c
  group GUI_DRV
    ../GUI_DRV/src/: button.c gui_basic.c gui_menu.c lcmdrv.c messagebox.c scrollbar.c text.c windows.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_conf.h
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 4.3.0
